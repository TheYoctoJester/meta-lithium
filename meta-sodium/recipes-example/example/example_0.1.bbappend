FOOBAR += "xyzzy"
